# Keil uVision project NORENV.uvprojx, settings and files
target NORENV (5060960::V5.06 update 7 (build 960)::.\ARMCCV5)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: NORENV +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H750xx
  c misc: --C99
  c include: ..\CORE;..\USER;..\USMART;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32H7xx_HAL_Driver\Inc;..\MALLOC;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\MPU;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\RTC;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\PCF8574;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\DHT11;..\HARDWARE\NRF24L01;..\HARDWARE\OV5640;..\HARDWARE\DCMI;..\HARDWARE\USART2;..\HARDWARE\TIMER;..\HARDWARE\SDMMC;..\HARDWARE\NAND;..\HARDWARE\JPEGCODEC;..\HARDWARE\SAI;..\HARDWARE\ES8388;..\FATFS\exfuns;..\FATFS\source;..\TEXT;..\PICTURE;..\AUDIOCODEC\wav;..\APP;..\MJPEG;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\LITTLEFS;..\SPIFFS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\SCRIPT\qspi_code_scf.scf
  link misc: --diag_suppress=6314,6329
  group USER
    ./: main.c stm32h7xx_it.c system_stm32h7xx.c stm32h7xx_hal_msp.c nfvfs.c benchmark.c
  group CORE
    ../CORE/: core_cm7.h cmsis_armcc.h cmsis_compiler.h startup_stm32h750xx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HALLIB
    ../HALLIB/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_sram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_nand.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDMMC/: sdmmc_sdcard.c
    ../HARDWARE/NAND/: ftl.c nand.c nandtester.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group MALLOC
    ../MALLOC/: malloc.c
  group README
    ../: readme.txt
  group LITTLEFS
    ../LITTLEFS/: lfs.c lfs_util.c lfs_brigde.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
  group SPIFFS
    ../SPIFFS/: spiffs_brigde.c spiffs_cache.c spiffs_check.c spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c
